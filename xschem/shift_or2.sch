v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 140 -220 0 1 {name=p1 lab=VDD
}
C {devices/iopin.sym} 140 -120 0 1 {name=p2 lab=VSS
}
C {devices/ipin.sym} 140 -170 0 0 {name=p33 lab=U[15:0]}
C {or2.sym} 300 -170 0 0 {name=x1[16:0]}
C {devices/opin.sym} 350 -170 0 0 {name=p3 lab=C[16:0]}
C {devices/lab_pin.sym} 270 -210 0 1 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 270 -130 0 1 {name=p6 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 260 -190 0 0 {name=p10 sig_type=std_logic lab=VSS,U[15:0]}
C {devices/lab_pin.sym} 260 -150 0 0 {name=p12 sig_type=std_logic lab=U[15:0],VSS}
