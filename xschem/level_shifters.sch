v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {level_shifter.sym} 10 0 0 0 {name=xsi[7:0]}
C {devices/ipin.sym} -30 0 0 0 {name=p1 lab=IN[7:0]}
C {devices/opin.sym} 40 0 0 0 {name=p2 lab=OUT[7:0]}
C {devices/iopin.sym} -10 30 0 1 {name=p3 lab=VSS}
C {devices/iopin.sym} -10 -30 0 1 {name=p4 lab=IVDD}
C {devices/iopin.sym} 0 -30 0 0 {name=p5 lab=OVDD}
