v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {decoder4.sym} 250 -170 0 0 {name=x1}
C {devices/iopin.sym} 140 -240 0 1 {name=p1 lab=VDD
}
C {devices/iopin.sym} 140 -100 0 1 {name=p2 lab=VSS
}
C {devices/ipin.sym} 140 -180 0 0 {name=p33 lab=IN[7:4]}
C {devices/lab_pin.sym} 250 -240 0 1 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 250 -100 0 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 600 -170 0 0 {name=p3 lab=C[16:0]}
C {devices/lab_pin.sym} 140 -160 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {shift_or2.sym} 480 -170 0 0 {name=x2}
C {devices/lab_pin.sym} 480 -240 0 1 {name=p5 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 480 -100 0 1 {name=p6 sig_type=std_logic lab=VSS}
