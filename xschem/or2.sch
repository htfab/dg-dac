v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {nor2.sym} 140 -120 0 0 {name=x1}
C {inverter.sym} 240 -120 0 0 {name=x2}
C {devices/iopin.sym} 100 -50 2 0 {name=p1 lab=VSS}
C {devices/iopin.sym} 100 -190 2 0 {name=p2 lab=VDD}
C {devices/ipin.sym} 100 -100 2 1 {name=p3 lab=B}
C {devices/ipin.sym} 100 -140 2 1 {name=p5 lab=A}
C {devices/opin.sym} 280 -120 0 0 {name=p10 lab=OUT}
C {devices/lab_pin.sym} 110 -160 0 1 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 110 -80 0 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 220 -150 0 1 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 220 -90 0 1 {name=p6 sig_type=std_logic lab=VSS}
