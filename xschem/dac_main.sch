v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 180 -220 0 1 {name=p102 lab=VSS}
C {devices/iopin.sym} 180 -380 0 1 {name=p3 lab=VDD}
C {devices/iopin.sym} 1090 -300 0 0 {name=p7 lab=VOUT}
C {devices/ipin.sym} 180 -320 2 1 {name=p118 lab=C[16:0]}
C {devices/lab_pin.sym} 540 -300 0 1 {name=p1 sig_type=std_logic lab=8*(A,B),A}
C {devices/ipin.sym} 180 -280 2 1 {name=p140 lab=D[15:0]}
C {ladder16.sym} 420 -300 0 0 {name=x1}
C {devices/lab_pin.sym} 420 -220 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 420 -380 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 970 -300 0 1 {name=p9 sig_type=std_logic lab=16*VOUT}
C {ladder15.sym} 850 -300 0 0 {name=x2}
C {devices/lab_pin.sym} 850 -220 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 850 -380 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 730 -320 0 0 {name=p5 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 730 -300 0 0 {name=p6 sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 730 -280 0 0 {name=p8 sig_type=std_logic lab=D[15:0]}
C {devices/lab_pin.sym} 300 -320 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 300 -300 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 -280 0 0 {name=p14 sig_type=std_logic lab=C[16:0]}
