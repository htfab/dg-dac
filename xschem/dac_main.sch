v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 180 -220 0 1 {name=p102 lab=VSS}
C {devices/iopin.sym} 180 -380 0 1 {name=p3 lab=VDD}
C {devices/iopin.sym} 1120 -300 0 0 {name=p7 lab=VOUT}
C {devices/ipin.sym} 180 -320 2 1 {name=p118 lab=C[16:0]}
C {devices/lab_pin.sym} 540 -300 0 1 {name=p1 sig_type=std_logic lab=8*(A,B),A}
C {devices/ipin.sym} 180 -280 2 1 {name=p140 lab=D[15:0]}
C {ladder.sym} 420 -300 0 0 {name=x1}
C {devices/lab_pin.sym} 420 -220 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 420 -380 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1000 -300 0 1 {name=p9 sig_type=std_logic lab=17*VOUT}
C {ladder.sym} 880 -300 0 0 {name=x2}
C {devices/lab_pin.sym} 880 -220 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 880 -380 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 760 -310 0 0 {name=p5 sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 760 -290 0 0 {name=p6 sig_type=std_logic lab=A}
C {ignore.sym} 300 -310 0 1 {name=l1}
C {ignore.sym} 760 -330 0 1 {name=l2}
C {devices/lab_pin.sym} 760 -270 0 0 {name=p8 sig_type=std_logic lab=VSS,D[15:0]}
C {devices/lab_pin.sym} 300 -330 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 300 -290 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 300 -270 0 0 {name=p14 sig_type=std_logic lab=C[16:0]}
