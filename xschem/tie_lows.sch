v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {tie_low.sym} 0 0 0 0 {name=xtie[7:0]}
C {devices/opin.sym} 70 0 0 0 {name=p1 lab=LO[7:0]}
C {devices/iopin.sym} 0 -40 0 1 {name=p2 lab=VDD}
C {devices/iopin.sym} 0 40 0 1 {name=p3 lab=VSS}
